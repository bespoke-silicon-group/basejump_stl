.lib '/gro/cad/arm180/TSMC_180_7_26_16/MOSIS_Logic_7_26_16/T-018-LO-SP-001/T018LOSP001_2_1/T018LOSP001_2_1/log018.l' FF
.include '/gro/cad/arm180/TSMC_180_7_26_16/ARM_7_26_16/TS02LB500-FB-000000 -- tsmc/cl018g/sc9_base_rvt/2008q3v01/cdl/sage-x_tsmc_cl018g_rvt.cdl'

.temp -40C

.malias pch P
.malias nch N

.param supply=1.9

v1 vdd 0 supply
v0 vss 0 0
